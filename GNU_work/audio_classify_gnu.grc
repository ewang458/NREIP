options:
  parameters:
    generate_options: qt_gui
    id: python_blk_test
    output_language: python
    title: Audio_Classification_GNU
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '16000'
  states: {}
- name: variable_qtgui_label_0
  id: variable_qtgui_label
  parameters:
    type: int
    value: '0'
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    samp_rate: samp_rate
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |-
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      import pandas as pd
      import librosa
      import torch
      import torch.nn as nn
      import torch.optim as optim
      from torch.utils.data import Dataset, DataLoader
      from sklearn.utils.class_weight import compute_class_weight
      from sklearn.metrics import classification_report, confusion_matrix
      import matplotlib.pyplot as plt
      import os
      from gnuradio import gr

      # CNN Model (must match your training architecture exactly)
      class AudioCNN(nn.Module):
          """CNN model for audio classification"""
          def __init__(self, num_classes=7):
              super(AudioCNN, self).__init__()
              self.conv1 = nn.Sequential(
                  nn.Conv2d(1, 32, 3, padding=1),
                  nn.BatchNorm2d(32),
                  nn.LeakyReLU(0.1),
                  nn.Conv2d(32, 32, 3, padding=1),
                  nn.BatchNorm2d(32),
                  nn.LeakyReLU(0.1),
                  nn.MaxPool2d(2),
                  nn.Dropout(0.25)
              )
              self.conv2 = nn.Sequential(
                  nn.Conv2d(32, 64, 3, padding=1),
                  nn.BatchNorm2d(64),
                  nn.LeakyReLU(0.1),
                  nn.Conv2d(64, 64, 3, padding=1),
                  nn.BatchNorm2d(64),
                  nn.LeakyReLU(0.1),
                  nn.MaxPool2d(2),
                  nn.Dropout(0.25)
              )
              self.conv3 = nn.Sequential(
                  nn.Conv2d(64, 128, 3, padding=1),
                  nn.BatchNorm2d(128),
                  nn.LeakyReLU(0.1),
                  nn.Conv2d(128, 128, 3, padding=1),
                  nn.BatchNorm2d(128),
                  nn.LeakyReLU(0.1),
                  nn.MaxPool2d(2),
                  nn.Dropout(0.25)
              )

              self.flatten_size = 128 * 16 * 27

              self.fc = nn.Sequential(
                  nn.Flatten(),
                  nn.Linear(self.flatten_size, 256),
                  nn.BatchNorm1d(256),
                  nn.LeakyReLU(0.1),
                  nn.Dropout(0.5),
                  nn.Linear(256, 128),
                  nn.BatchNorm1d(128),
                  nn.LeakyReLU(0.1),
                  nn.Dropout(0.5),
                  nn.Linear(128, num_classes)
              )

          def forward(self, x):
              x = self.conv1(x)
              x = self.conv2(x)
              x = self.conv3(x)
              x = self.fc(x)
              return x


      class audio_classifier(gr.sync_block):
          """
          Real-time audio classifier for GNU Radio
          
          Processes 7-second audio windows with 1-second stride
          Outputs classification results in real-time with message port for class names
          """
          
          CLASS_NAMES = [
              'Communication',
              'Gunshot',
              'Footsteps',
              'Shelling',
              'Vehicle',
              'Helicopter',
              'Fighter Jet'
          ]
          
          def __init__(self, model_path='best_model.pth', sample_rate=16000, 
                       confidence_threshold=0.5, min_consecutive=2):
              """
              Initialize the audio classifier block
              
              Args:
                  model_path: Path to trained .pth model file
                  sample_rate: Audio sample rate (must match training - 16kHz)
                  confidence_threshold: Minimum confidence for valid detection (0-1)
                  min_consecutive: Minimum consecutive detections before reporting
              """
              gr.sync_block.__init__(
                  self,
                  name="audio_classifier",
                  in_sig=[np.float32],
                  out_sig=[np.int32, np.float32]  # class_id, confidence
              )
              
              # Register message port for outputting class names
              self.message_port_register_out(pmt.intern('class_name'))
              
              self.sample_rate = sample_rate
              self.duration = 7  # seconds
              self.window_size = self.sample_rate * self.duration  # 112000 samples
              self.stride = self.sample_rate  # 1 second stride = 16000 samples
              self.confidence_threshold = confidence_threshold
              self.min_consecutive = min_consecutive
              
              # Set up GNU Radio parameters for sliding window
              self.set_history(self.window_size)
              self.set_decimation(self.stride)
              
              # Load model
              print(f"Loading model from {model_path}...")
              self.device = torch.device('cuda' if torch.cuda.is_available() else 'cpu')
              print(f"Using device: {self.device}")
              
              self.model = AudioCNN(num_classes=len(self.CLASS_NAMES))
              self.model.load_state_dict(torch.load(model_path, map_location=self.device))
              self.model.eval()
              self.model.to(self.device)
              print("Model loaded successfully!")
              
              # Mel-spectrogram parameters (must match training)
              self.n_mels = 128
              self.fmax = 8000
              self.hop_length = 512
              self.n_fft = 2048
              
              # State tracking for consecutive detections
              self.last_class = -1
              self.consecutive_count = 0
              self.current_event_class = -1
              
          def extract_mel_spectrogram(self, audio):
              """
              Extract normalized mel-spectrogram from audio array
              
              Args:
                  audio: numpy array of audio samples
                  
              Returns:
                  Normalized mel-spectrogram
              """
              try:
                  # Ensure correct length
                  if len(audio) < self.window_size:
                      audio = np.pad(audio, (0, self.window_size - len(audio)))
                  elif len(audio) > self.window_size:
                      audio = audio[-self.window_size:]
                  
                  # Extract mel-spectrogram
                  mel_spec = librosa.feature.melspectrogram(
                      y=audio,
                      sr=self.sample_rate,
                      n_mels=self.n_mels,
                      fmax=self.fmax,
                      hop_length=self.hop_length,
                      n_fft=self.n_fft
                  )
                  
                  # Convert to dB and normalize
                  mel_spec_db = librosa.power_to_db(mel_spec, ref=np.max)
                  mel_spec_norm = (mel_spec_db - mel_spec_db.min()) / (mel_spec_db.max() - mel_spec_db.min() + 1e-8)
                  
                  return mel_spec_norm
                  
              except Exception as e:
                  print(f"Error extracting mel-spectrogram: {e}")
                  return None
          
          def work(self, input_items, output_items):
              """
              Process audio and generate classifications
              
              Args:
                  input_items: Input audio stream
                  output_items: Output classification and confidence
                  
              Returns:
                  Number of items produced
              """
              in0 = input_items[0]
              out_class = output_items[0]
              out_conf = output_items[1]
              
              # Get the last 7 seconds of audio (sliding window)
              audio_window = in0[-self.window_size:]
              
              # Extract mel-spectrogram
              mel_spec = self.extract_mel_spectrogram(audio_window)
              
              if mel_spec is None:
                  out_class[:] = -1  # Error indicator
                  out_conf[:] = 0.0
                  self.send_class_message("ERROR", 0.0)
                  return len(output_items[0])
              
              # Run inference
              try:
                  with torch.no_grad():
                      # Prepare input tensor: [batch, channels, height, width]
                      mel_tensor = torch.FloatTensor(mel_spec).unsqueeze(0).unsqueeze(0)
                      mel_tensor = mel_tensor.to(self.device)
                      
                      # Get model output
                      output = self.model(mel_tensor)
                      
                      # Apply softmax to get probabilities
                      probabilities = torch.softmax(output, dim=1)
                      confidence, predicted_class = probabilities.max(dim=1)
                      
                      predicted_class = predicted_class.item()
                      confidence = confidence.item()
                      
                      # Apply confidence threshold
                      if confidence < self.confidence_threshold:
                          predicted_class = -1  # Below threshold
                          confidence = 0.0
                      
                      # Track consecutive detections
                      if predicted_class == self.last_class and predicted_class != -1:
                          self.consecutive_count += 1
                      else:
                          self.consecutive_count = 1
                          self.last_class = predicted_class
                      
                      # Only report after minimum consecutive detections
                      if self.consecutive_count >= self.min_consecutive:
                          if self.current_event_class != predicted_class:
                              self.current_event_class = predicted_class
                              if predicted_class != -1:
                                  class_name = self.CLASS_NAMES[predicted_class]
                                  print(f"DETECTION: {class_name} (confidence: {confidence:.2f})")
                                  self.send_class_message(class_name, confidence)
                              else:
                                  self.send_class_message("NO DETECTION", confidence)
                          
                          out_class[:] = predicted_class
                          out_conf[:] = confidence
                      else:
                          out_class[:] = -1  # Not enough consecutive detections yet
                          out_conf[:] = confidence
                      
              except Exception as e:
                  print(f"Error during inference: {e}")
                  out_class[:] = -1
                  out_conf[:] = 0.0
                  self.send_class_message("ERROR", 0.0)
              
              return len(output_items[0])
          
          def send_class_message(self, class_name, confidence):
              """
              Send class name as a PMT message
              
              Args:
                  class_name: String name of the detected class
                  confidence: Confidence score for the detection
              """
              # Create a PMT dictionary with class name and confidence
              msg_dict = pmt.make_dict()
              msg_dict = pmt.dict_add(msg_dict, pmt.intern("class"), pmt.intern(class_name))
              msg_dict = pmt.dict_add(msg_dict, pmt.intern("confidence"), pmt.from_double(confidence))
              
              # Send the message
              self.message_port_pub(pmt.intern('class_name'), msg_dict)
    alias: classify_data_block
    example_param: '1.0'
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}

connections:
- [audio_source_0, '0', epy_block_0, '0']
- [epy_block_0, '0', blocks_message_debug_0, print]
- [epy_block_0, '0', qtgui_number_sink_0, '0']
- [epy_block_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
